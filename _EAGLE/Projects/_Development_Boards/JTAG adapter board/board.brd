# Repository kihunsong22/hardware_projects (continued)

## EAGLE design _EAGLE/Projects/RFID_SensorTag/board_V1_edit.brd

Parts:
BATT: PINHD-1X2; 1X02
C1, C2, C4: 100nF; C0805
CURRENT: PINHD-1X2; 1X02
JP_3V3: PINHD-1X2; 1X02
JP_GND: PINHD-1X2; 1X02
JP_VBATT/5V: PINHD-1X2; 1X02
M1: RFID-RC522
M2: BATTERY-CHARGER-LI-PROT
OLED_1, OLED_2: CONN_04; 1X04
S1: SWITCH-SPDT-PTH-11.6X4.0MM; SWITCH_SPDT_PTH_11.6X4.0MM
U1: MAXIM_ELECTRONICS_MAX40200AUK+MAXIM_ELECTRONICS_M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; MAXIM_ELECTRONICS_MAX40200AUK+_0
U$1: NANO_ICSP-REMOVED
X1: 53048-02

Connections:
3.3V: C1.1, JP_3V3.1, JP_3V3.2, M1.3V3 (1), OLED_1.3, OLED_2.4, U$1.3.3V
BATT_VOUT: S1.2, U1.1 (VDD), U1.3 (EN)
BUZZER: U$1.D8
GND: C1.2, C2.2, C4.2, JP_GND.1, JP_GND.2, M1.GND (3), M2.IN-, M2.OUT-, OLED_1.4, OLED_2.3, U1.2 (GND), U1.4 (NC), U$1.GND
I2C_SCL: OLED_1.2, OLED_2.2, U$1.A5
I2C_SDA: OLED_1.1, OLED_2.1, U$1.A4
unnamed: BATT.1, M2.B+, X1.1
unnamed: CURRENT.1, M2.OUT+, S1.1 (O)
unnamed: CURRENT.2, S1.3 (S)
unnamed: BATT.2, M2.B-, X1.2
RFID_RST: M1.RST (2), U$1.D9
SPI_MISO: M1.MISO (5), U$1.D12
SPI_MOSI: M1.MOSI (6), U$1.D11
SPI_SCK: M1.SCK (7), U$1.D13
SPI_SS: M1.SS (8), U$1.D10
V_BATT: C2.1, C4.1, JP_VBATT/5V.1, JP_VBATT/5V.2, U1.5 (OUT), U$1.5V (5.5V)

Board: 2 copper layers, 95.0 x 60.0 mm, 16 parts (0 on the bottom side), 15 nets.

## EAGLE design _EAGLE/Projects/_Prototyping_Boards/IM_L400_prototype board/board.brd

Parts:
C1: C-EUC0805; C0805
J1: CONN_06LOCK; 1X06_LOCK
J2: CONN_07LOCK; 1X07_LOCK
RST: 6.0X3.5mm; TACTILE_SWITCH_SMD_6.0X3.5MM
U$1: IM-L400
WAKE: 6.0X3.5mm; TACTILE_SWITCH_SMD_6.0X3.5MM

Connections:
GND: C1.1, J1.3, J2.5, RST.2, U$1.GND, U$1.GND1, WAKE.2
unnamed: J1.5, U$1.RX
unnamed: J1.4, U$1.TX
unnamed: J1.2, U$1.LED
unnamed: J1.1, U$1.WAKE, WAKE.1
unnamed: J2.1, U$1.BOOT
unnamed: J2.3, U$1.DBG_RX
unnamed: J2.4, U$1.DBG_TX
unnamed: J2.6, RST.1, U$1.RST
unnamed: J2.7, U$1.TEST
VCC: C1.2, J1.6, J2.2, U$1.VCC, U$1.VCC1

Board: 2 copper layers, 29.0 x 21.8 mm, 6 parts (0 on the bottom side), 11 nets.

## EAGLE design _PCB/ESP12_DevBoard/ESP-12E Dev Board.brd

Parts:
C1, C4: 10uF; C0805
C2, C3, C8: 100nF; C0805
C5, C10: 22uF; C0805
C6: 100uF; SMC_B
C7, C9: 220uF; UD-6,3X7,7_NICHICON
D1, D2: 1N5819W; SOD-123
J1: ZX62-B-5PA(33); ZX62B5PA33
JP1: POWER_JACKSLT; POWER_JACK_SLOT
LED1: green; CHIP-LED0805
R1, R2, R3, R4, R5, R6: 10k; R0805
R7: 470Ω; R0805
S1: RST; TACTILE_SWITCH_SMD_6.0X3.5MM
S2: FLASH; TACTILE_SWITCH_SMD_6.0X3.5MM
U1: 5V_REG; SOT230P700X170-4N
U2: 3V3_REG; SOT230P700X170-4N

Connections:
3.3V: C9.+, C10.2, R1.1, R2.1, R3.1, R4.1, R6.1, U2.2 (OUT), U2.4 (VOUT); also elsewhere on the board
5V: C5.1, C6.+, C7.+, D2.-, U1.2 (OUT), U1.4 (VOUT), U2.3 (IN); also elsewhere on the board
12V: C4.1, D1.-, U1.3 (IN); also elsewhere on the board
D+_USB: J1.D+; also elsewhere on the board
D-_USB: J1.D-; also elsewhere on the board
EN: C3.2, R3.2; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.-, C7.-, C8.1, C9.-, C10.1, J1.GND, J1.SHIELD_1 (SHIELD), J1.SHIELD_2 (SHIELD), J1.SHIELD_3 (SHIELD), J1.SHIELD_4 (SHIELD), J1.SHIELD_5 (SHIELD), J1.SHIELD_6 (SHIELD), JP1.GND@1 (GNDBREAK), JP1.GND@2 (GND), LED1.C, R5.1, S1.2, S2.2, U1.1 (GND), U2.1 (GND); also elsewhere on the board
GPIO0: R1.2, R7.1; also elsewhere on the board
GPIO2: R2.2; also elsewhere on the board
GPIO15: R5.2; also elsewhere on the board
unnamed: C1.2, D1.+, JP1.PWR
unnamed: LED1.A, R6.2
unnamed: C8.2, D2.+, J1.VCC
POWER1: R7.2, S2.1
RST: C2.2, R4.2, S1.1; also elsewhere on the board

Parts:
C11, C13: 100nF; C0805
C12: 100uF; SMC_B
J2, J4: I2C; 5267-4
J3: LCD; 5267-8
J5: LCD_BACKLIGHT; 5267-2
J6: TEMP/HUM; 5267-4
J7: RADON; 5267-4
J8: DUST; 5267-4
J9: ADC; 5267-3
J10: BTN1; 5267-3
J11: BTN2; 5267-3
Q1: UMH3N; SOT65P210X100-6N
R10, R11: 470Ω; R0805
R12: 47k(1%); R0805
R13: 10k(1%); R0805
SJR1: ESP-12E; ESP8266-ESP12E
U3: CH340C; SOIC16
VR1: RK09K1130AAU; RK09K1130BGM

Connections:
3.3V: C11.2, C12.+, C13.2, J6.P$2 (-2), SJR1.8 (VCC), U3.4 (V3), U3.16 (VCC); also elsewhere on the board
5V: J2.P$2 (-2), J3.P$2 (-2), J4.P$2 (-2), J5.P$1 (-1), J8.P$2 (-2), J9.P$2 (-2), J10.P$2 (-2), J11.P$2 (-2), VR1.3; also elsewhere on the board
12V: J7.P$2 (-2); also elsewhere on the board
ADC: R12.1, R13.2, SJR1.2 (ADC)
CS0_ESP: SJR1.17 (CS0)
D+_USB: U3.5 (D+); also elsewhere on the board
D-_USB: U3.6 (D-); also elsewhere on the board
DTR: Q1.2, Q1.4, U3.13 (DTR)
EN: SJR1.3 (EN); also elsewhere on the board
GND: C11.1, C12.-, C13.1, J2.P$1 (-1), J3.P$1 (-1), J3.P$8 (-8), J4.P$1 (-1), J6.P$1 (-1), J7.P$1 (-1), J8.P$1 (-1), J9.P$1 (-1), J10.P$1 (-1), J11.P$1 (-1), R13.1, SJR1.9 (GND), U3.1 (GND), VR1.1; also elsewhere on the board
GPIO0: Q1.3, R11.1, SJR1.12 (GPIO0); also elsewhere on the board
GPIO2: J8.P$4 (-4), SJR1.11 (GPIO2); also elsewhere on the board
GPIO4: J2.P$4 (-4), J3.P$5 (-5), J4.P$4 (-4), J6.P$4 (-4), SJR1.13 (GPIO4)
GPIO5: J2.P$3 (-3), J3.P$4 (-4), J4.P$3 (-3), J6.P$3 (-3), SJR1.14 (GPIO5)
GPIO9: SJR1.19 (GPIO9)
GPIO10: SJR1.20 (GPIO10)
GPIO12: J7.P$4 (-4), SJR1.6 (GPIO12)
GPIO13: J10.P$3 (-3), SJR1.7 (GPIO13)
GPIO14: R10.1, SJR1.5 (GPIO14)
GPIO15: J11.P$3 (-3), SJR1.10 (GPIO15); also elsewhere on the board
GPIO16: SJR1.4 (GPIO16)
LED+: J3.P$7 (-7), J5.P$2 (-2)
MISO_ESP: SJR1.18 (MISO)
MOSI_ESP: SJR1.21 (MOSI)
unnamed: J3.P$3 (-3), VR1.2
unnamed: J9.P$3 (-3), R12.2
unnamed: J7.P$3 (-3), R10.2
unnamed: J8.P$3 (-3), R11.2
RST: Q1.6, SJR1.1 (RST); also elsewhere on the board
RTS: Q1.1, Q1.5, U3.14 (RTS)
RXD: SJR1.15 (RXD), U3.2 (TX)
SCLK_ESP: SJR1.22 (SCLK)
TXD: SJR1.16 (TXD), U3.3 (RX)

Notes on the sheet:
SCL
SDA
sensor_TX
sensor_RX
Multiply ADC reading by 5.7 to get analog voltage(0~6V)
RST(N.C)
LED+
LED-
SCL/SDA : D1/D2 (5/4) 미세먼지센서: D3/D4 (0/2) 라돈센서: D5/D6 (14/12) Button1: D7 (13) Button2: D8 (15) Analog: ADC
VDD
VSS

Board: 2 copper layers, 52.0 x 60.0 mm, 47 parts (0 on the bottom side), 30 nets.

File _PCB/ESP12_DevBoard/OUTPUT/BOM.xlsx:

| BOM for ESP-12E Dev Board
 | Qty | Designator | Value | Package | MANUFACTURER_NAME | MANUFACTURER_PART_NUMBER | Total Price | Price | Link
 | 2 | C1, C4 | 10uF | C0805 | Samsung Electro-Mechanics | CL21A106KAYNNNE | 2.8000000000000001E-2 | 1.4E-2 | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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
 | 6 | C2, C3, C8, C11, C13 | 0.1uF | C0805 | Samsung Electro-Mechanics | CL21F104ZBCNNNC | 3.6000000000000004E-2 | 6.0000000000000001E-3 | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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
 | 2 | C5, C10 | 22uF | C0805 | Samsung Electro-Mechanics | CL21A226MAQNNNF | 0.19220000000000001 | 9.6100000000000005E-2 | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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
 | 2 | C6, C12 | 100uF | SMC_B | AVX | TAJB107M010RNJ | 0.27039999999999997 | 0.13519999999999999 | https://lcsc.com/product-detail/Tantalum-Capacitors_AVX_TAJB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
 | 2 | C7, C9 | 220uF | 6.3*7.7mm | ROQANG | VT1C221M0607 | 5.2999999999999999E-2 | 2.6499999999999999E-2 | https://lcsc.com/product-detail/Aluminum-Electrolytic-Capaci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
 | 2 | D1, D2 | 1N5819W | SOD-123F | Shandong Jingdao Microelectronics | 1N5819W | 2.3199999999999998E-2 | 1.1599999999999999E-2 | https://lcsc.com/product-detail/Schottky-Barrier-Diodes-SBD_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
 | 1 | J1 | ZX62-B-5PA(33) | ZX62B5PA33 | Hirose | ZX62-B-5PA(33) | 0.43109999999999998 | 0.43109999999999998 | https://lcsc.com/product-detail/USB-Connectors_HRS_ZX62-B-5P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
 | 5 | J2, J4, J6, J7, J10 | 4 |  | MOLEX | 99990988 | 0.19900000000000001 | 3.9800000000000002E-2 | https://lcsc.com/product-detail/Wire-To-Board-Wire-To-Wire-C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
 | 1 | J3 | 8 |  | MOLEX | 99990992 | 0.51700000000000002 | 0.51700000000000002 | https://www.mouser.com/ProductDetail/Molex/22-03-5085?qs=sGA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
 | 1 | J5 | 2 |  | MOLEX | 22035025 | 3.27E-2 | 3.27E-2 | https://lcsc.com/product-detail/Wire-To-Board-Wire-To-Wire-C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
 | 3 | J8, J9, J11 | 3 |  | MOLEX | 22035035 | 9.7500000000000003E-2 | 3.2500000000000001E-2 | https://lcsc.com/product-detail/Wire-To-Board-Wire-To-Wire-C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
 | 1 | JP1 | 5.5*2.1mm | 14.0*9.0mm | Korean Hroparts Elec | DC-005-20A | 5.8599999999999999E-2 | 5.8599999999999999E-2 | https://lcsc.com/product-detail/Power-Connectors_Korean-Hrop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
 | 1 | LED1 | green | LED0805 | Orient | ORH-G35A | 1.03E-2 | 1.03E-2 | https://lcsc.com/product-detail/Light-Emitting-Diodes-LED_08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
 | 1 | Q1 | UMH3N | SOT65P210X100-6N | Changjiang Electronics Tech | UMH3N | 2.18E-2 | 2.18E-2 | https://lcsc.com/product-detail/Digital-Transistors_Changjia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
 | 7 | R1, R2, R3, R4, R5, R6, R13 | 10k | R0805 | Uniroyal Elec | 0805W8F1002T5E | 8.3999999999999995E-3 | 1.1999999999999999E-3 | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
 | 1 | R12 | 47k(1%) | R0805 | Uniroyal Elec | 0805W8F4702T5E | 1.2999999999999999E-3 | 1.2999999999999999E-3 | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
 | 3 | R7, R10, R11 | 470 | R0805 | Guangdong Fenghua Advanced Tech | RS-05K471JT | 3.0000000000000001E-3 | 1E-3 | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
 | 2 | S1, S2 | pushbutton | 6.0*3.5mm | HYP (Hongyuan Precision) | 1TS002B-2300-5000-CT | 4.48E-2 | 2.24E-2 | https://lcsc.com/product-detail/Others_HYP-1TS002B-2300-5000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
 | 1 | SJR1 | ESP-12E | ESP8266-ESP12E | AI-Thinker | ESP-12E | 2.0472999999999999 | 2.0472999999999999 | https://lcsc.com/product-detail/WIFI-Modules_ESP-12E_C89297.html
 | 1 | U1 | 5V regulator | SOT-223 | Diodes Incorporated | AZ1117H-5.0TRE1 | 6.5199999999999994E-2 | 6.5199999999999994E-2 | https://lcsc.com/product-detail/Low-Dropout-Regulators-LDO_D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
 | 1 | U2 | 3.3V regulator | SOT-223 | Diodes Incorporated | AZ1117H-3.3TRG1 | 0.06 | 0.06 | https://lcsc.com/product-detail/Low-Dropout-Regulators-LDO_D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
 | 1 | U3 | CH340C | SOP-16_150mil | Jiangsu Qin Heng | CH340C | 0.28160000000000002 | 0.28160000000000002 | https://lcsc.com/product-detail/USB_CH340C_C84681.html
 | 1 | VR1 | 10k variable | RK09K1130BGM | ALPS Electric | RK09K1130AAU | 0.33250000000000002 | 0.33250000000000002 | https://lcsc.com/product-detail/Potentiometers-Variable-Resi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
 |  |  |  |  |  |  | SUM
 |  |  |  |  |  |  | 4.8148999999999997

## EAGLE design _PCB/_Prototyping_Boards/Universal PCB/DoubleBoard_TypeC.brd

Parts:
J1, J2: TYPE-C-31-M-17
J3, J4: USB_MICRO-B_FEMALE-SMT; USB-B-MICRO-SMD

Connections:
5V: J2.VBUS, J2.VBUS_2, J3.VBUS
GND: J2.GND, J2.GND_2, J3.GND
unnamed: J3.SHIELD1 (SHIELD), J3.SHIELD2 (SHIELD), J3.SHIELD3 (SHIELD)
unnamed: J1.VBUS, J1.VBUS_2, J4.VBUS
unnamed: J4.SHIELD1 (SHIELD), J4.SHIELD2 (SHIELD), J4.SHIELD3 (SHIELD)
unnamed: J1.GND, J1.GND_2, J4.GND

Board: 2 copper layers, 4 parts (0 on the bottom side), 6 nets.

## Commit log

2018-01-21 files uploaded
2018-01-22 nothing
2018-01-22 dir name edited
2018-01-24 added NRF24_getsettings
2018-01-24 improved NRF24getsettings
2018-01-25 removed
2018-02-09 added platformIO buils
2018-02-09 pio usage
2018-02-09 pio home
2018-02-10 git global username
2018-02-10 git global email
2018-02-14 added some unomacro
2018-04-14 GP2Y10
2018-04-17 MLX90615
2018-04-23 MLX90615 added
2018-05-06 TMP007
2018-05-06 global settings test
2018-05-06 TMP update
2018-05-15 DTS-SIL300 sensor added
2018-06-05 general update with LoRa
2018-06-12 lora setting file
2018-06-21 EMA, LoRa added
2018-06-23 EMA filter added
2018-06-29 PCB added
2018-06-29 misc stuff and datasheets added
2018-07-01 fixed large file prob
2018-07-01 thickend power trace width
2018-07-02 optimized routes
2018-07-03 datasheet
2018-07-04 PCB, EMA filter update
2018-07-07 pro mini board checkpoint
2018-07-07 checkpoint
2018-07-08 library update
2018-07-09 board update
2018-07-11 prototype board optimization
2018-07-12 timer added
2018-07-14 MATLAB arduino source
2018-07-14 PCB optimization
2018-07-16 airMouse first commit
2018-07-28 air mouse project added
2018-07-30 TTGO board example code
2018-08-01 OLED
2018-08-01 prototype board update
2018-08-02 fixed issues - working version
2018-08-02 SX1278 sample
2018-08-02 board updates, LoRa
2018-08-03 prototype PCB, air mouse example code
2018-08-03 ESP8266 support
2018-08-03 prototype board finished
2018-08-04 board with CP2102 TTL module
2018-08-04 final prototype
2018-08-04 really final prototype
2018-08-08 IMU mouse PCB, 3D housing
2018-08-08 IMU mouse PCB update
2018-08-09 IMU mouse PCB
2018-08-10 proto board last save + update
2018-08-21 arduino-python plotting
2018-08-28 fixed errors
2018-08-28 proto board update
2018-08-29 IMU + proto board update
2018-09-05 IMU code, PCB update
2018-09-05 IMU mouse code update_final1
2018-09-10 IM-L400 prototype board
2018-09-10 LoRa PCB update
2018-09-11 IM-L400 update
2018-09-16 LoRa update
2018-09-19 cleanup
2018-09-20 SKT LoRa update
2018-09-27 LoRa
2018-10-02 weather API code
2018-10-03 server update
2018-10-16 LoRa gateway update
2018-10-17 LoRa code update
2018-10-22 should theoretically work
2018-10-23 successful code 1
2018-10-25 project update
2018-10-25 autodesk eagle update
2018-10-26 MAKER project
2018-10-28 LoRa board update
2018-10-30 prototype board complete
2018-11-02 BCAQS1187 sensor
2018-11-02 LoRa GPS tracker update
2018-11-03 IMU mouse update
2018-11-03 PCB update
2018-11-03 tracker-GPS data
2018-11-12 GPS tracker server complete
2018-11-12 removed API key
2018-11-14 GPS tracker update_cleanup
2018-11-15 nRF24L01 files
2018-11-15 reduced size
2018-11-19 MAKER node update
2018-11-26 Backlink to CADLAB.io has been added.
2018-11-29 LoRa sensor + universal PCB
2018-12-04 CUART converter
2018-12-04 CH340e design complete
2018-12-06 CH340E converter complete + LoRa sensor node
2018-12-13 CH340E board panelized
2018-12-15 error correciton
2018-12-15 pictures
2018-12-17 LoRa sensor node PCB update
2018-12-23 clean..
2019-01-25 update + STM32 dev board design
2019-01-30 library update+RFID project
2019-02-01 PCB - RFID system update
2019-02-02 PCB schematic update
2019-02-03 PCB ver1
2019-02-04 RFID PCB v2
2019-02-05 RFID tag PCB first production
2019-02-11 RFID system update
2019-02-17 RFID system PCB V1 edit
2019-02-17 arduino update
2019-02-18 RFID system PCB PCB V2
2019-02-18 RFID system V2 out
2019-03-11 RFID 3D housing
2019-03-23 RFID system 3D housing
2019-04-19 ESP12E dev board pcb update
2019-04-22 ESP12E dev board schematic V1
2019-04-22 Eagle PCB changeFont scripts
2019-04-25 PCB schematic final V1
2019-04-25 PCB artwork
2019-04-26 PCB layout V1
2019-04-27 PCB artwork V1
2019-04-27 final artwork with gerbers
2019-04-29 ESP-12E dev board V1 complete with gerbers and BOM
2019-04-29 PCB edit
2019-04-29 PCB V1.1 update
2019-05-03 final edit sample edit
2019-05-03 V1.2: GND plane issue fixed + optimized routes
2019-05-13 PCB V1.3 update
2019-05-13 optimization _ gerber errors
2019-05-13 PCB edit, broken gerber, BOM to be updated
2019-05-13 V1.3 update
2019-05-17 BOM update: gerber errors present
2019-05-19 PCB BOM update
2019-05-23 ESP-12e dev board PCB 1.4 update
2019-05-26 ESP12 dev board V1.4 final commit
2019-05-28 library update + PCB BOM
2019-05-30 ESP12 dev board PCB update
2019-06-06 AWS iot
2019-06-06 removed keys
2019-06-06 gitignore
2019-06-07 relay control server
2019-06-10 relayWebControl PHP server
2019-06-10 relayWebControl server iframe reload
2019-06-10 ESP-12 Dev Board screw hole fix
2019-06-11 ESP-12E Dev Board level shifter edit
2019-06-11 ESP12 board PADS format added + gerber update
2019-06-12 relayWebControl: uno wifi rev2 code update, web repeating function added
2019-06-12 relayWebControl: repeating function
2019-06-17 code changed for Uno WiFi Rev.2
2019-06-20 refactoring for advanced features
2019-06-20 security alert
2019-06-24 library update + relay control reservation view update
2019-06-25 relay web control update
2019-06-25 hardware code, devices2, upload2, devices.js fix - index2 to be fixed
2019-06-25 encoding error
2019-06-26 잘될거야....
2019-06-26 seems to work after integration
2019-07-03 wifi auto reconnect
2019-07-04 mini-SPOX 8 pin hole size
2019-07-05 LoRa range test code - needs work
2019-07-10 BQ2057 charging circuit
2019-07-29 relayWebControl database
2019-08-01 removed relay_web_control, updated arduino library
2019-08-13 Hroparts Type-C-M-17 part library added
2019-08-20 schematics + library update
2019-08-23 Type-C Hroparts M-17 footprint modded for easier soldering
2019-09-15 PCB misc update
2019-09-17 added samples
2019-11-09 SAMD21 dev board update
2019-11-27 library
2019-11-28 ATMEGA328P dev board
2019-12-10 ESP12 PCB updated for JLCPCB
2019-12-10 ESP-12 PCB finalized for JLCPCB orders
2019-12-16 removed arduino libraries
2019-12-24 custom library, library cleanup
2019-12-25 PCB library edit
2020-01-04 I2S mic test code
2020-01-10 Type-C power board, PCB library update
2020-01-11 Type-C power board panelization, gerbers
2020-01-13 Type-C proto PCB
2020-01-13 routing error, gerber files
2020-01-14 RFM98 RadioHead code
2020-01-19 MULTIPLE UPDATES
2020-02-23 UTO-NBL-52A PCB lib symbol, UV case update
2020-02-23 UTO-NBL-52A Eagle Library complete
2020-03-07 Type-C power port design error fix
2020-03-07 Type-C power port PCB panelization V1.1.0
2020-03-08 EAGLE change text script, shortcut keys script updated;
2020-03-09 EAGLE design blocks - BQ21040DBVR charging IC, DW01/FS8205A protection IC
2020-03-10 EAGLE library - removed solder paster for Tag-Connect footprint
2020-03-11 EAGLE Library - created SMD contact pads, with and without 6.0*3.5mm switch
2020-03-13 EAGLE library update
2020-03-16 LT spice simulation-low pass filter & project cleanup
2020-03-25 EAGLE: added/fixed joystick library
2020-03-26 JLCPCB 2-layer Design Rule
2020-03-26 EAGLE: created new set of angrypig7 libraries
2020-03-26 EAGLE: diode library
2020-03-27 EAGLE: angrypig7-transistors library symbol error fix
2020-04-01 EAGLE: angrypig7-Diode library added Rectifiers, updated Sparkfun EAGLE libary, other updates on EAGLE library
2020-04-01 EAGLE: seperated IC-Power from IC library
2020-04-02 EAGLE: library update
2020-04-02 EAGLE: desgin block - BQ21040 charging circuit with power switch MOSFET
2020-04-04 PCB library - angrypig7-switches, gitignore, removed EAGLE temporary files
2020-04-04 EAGLE library: seperated angrypig7-Connector-Programming, updated Tag-Connect library
2020-04-04 PCB: connector lib update, created j-link adapter board project
2020-04-04 PCB: programming connector lib update
2020-04-04 PCB: conn lib update, j-link adapter board schematics somewhat done
2020-04-05 PCB lib update, J-Link adapter pcb update
2020-04-05 PCB: JTAG adapter board update
2020-04-06 JTAG board V1
2020-04-06 moved JTAG adapter baord to a new repo
2020-04-12 removed stm32
2020-04-13 EAGLE lib: updated contact pads for less shorted signals
2020-04-13 1.27mm 2*5 mini SWD pin connector update
2020-04-16 removed EAGLE files
2020-11-20 ESP8266-BME680-InfluxDB-Grafana
2020-11-20 secrets.h
2022-11-26 93LC76 EEPROM data extractor
2023-01-01 unused ref docs removal
2023-06-08 ESP32 C3 WIP, MPU6xxx WHOAMI

Notices in the files:
parts and their libraries:
diy-modules: Released under the Creative Commons Attribution 4.0 International License: http://creativecommons.org/licenses/by/4.0
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
