# Repository kihunsong22/hardware_projects

## EAGLE design _PCB/ESP12_DevBoard/ESP-12E Dev Board_with_level_shifter.brd

Parts:
C1, C4: 10uF; C0805
C2, C3, C8: 100nF; C0805
C5, C10: 22uF; C0805
C6: 100uF; SMC_B
C7, C9: 220uF; UD-6,3X7,7_NICHICON
D1, D2: 1N5819W; SOD-123
J1: ZX62-B-5PA(33); ZX62B5PA33
JP1: POWER_JACKSLT; POWER_JACK_SLOT
LED1: green; CHIP-LED0805
R1, R2, R3, R4, R5, R6: 10k; R0805
R7: 470Ω; R0805
S1: RST; TACTILE_SWITCH_SMD_6.0X3.5MM
S2: FLASH; TACTILE_SWITCH_SMD_6.0X3.5MM
U1: 5V_REG; SOT230P700X170-4N
U2: 3V3_REG; SOT230P700X170-4N

Connections:
3.3V: C9.+, C10.2, R1.1, R2.1, R3.1, R4.1, R6.1, U2.2 (OUT), U2.4 (VOUT); also elsewhere on the board
5V: C5.1, C6.+, C7.+, D2.-, U1.2 (OUT), U1.4 (VOUT), U2.3 (IN); also elsewhere on the board
12V: C4.1, D1.-, U1.3 (IN); also elsewhere on the board
D+_USB: J1.D+; also elsewhere on the board
D-_USB: J1.D-; also elsewhere on the board
EN: C3.2, R3.2; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.-, C7.-, C8.1, C9.-, C10.1, J1.GND, J1.SHIELD_1 (SHIELD), J1.SHIELD_2 (SHIELD), J1.SHIELD_3 (SHIELD), J1.SHIELD_4 (SHIELD), J1.SHIELD_5 (SHIELD), J1.SHIELD_6 (SHIELD), JP1.GND@1 (GNDBREAK), JP1.GND@2 (GND), LED1.C, R5.1, S1.2, S2.2, U1.1 (GND), U2.1 (GND); also elsewhere on the board
GPIO0: R1.2, R7.1; also elsewhere on the board
GPIO2: R2.2; also elsewhere on the board
GPIO15: R5.2; also elsewhere on the board
unnamed: C1.2, D1.+, JP1.PWR
unnamed: LED1.A, R6.2
unnamed: C8.2, D2.+, J1.VCC
POWER1: R7.2, S2.1
RST: C2.2, R4.2, S1.1; also elsewhere on the board

Parts:
C11, C12, C14, C15: 100nF; C0805
C13: 100uF; SMC_B
J2, J4: I2C; 5267-4
J3: LCD; 5267-8
J5: LCD_BACKLIGHT; 5267-2
J6: TEMP/HUM; 5267-4
J7: RADON; 5267-4
J8: DUST; 5267-4
J9: ADC; 5267-3
J10: BTN1; 5267-3
J11: BTN2; 5267-3
Q1: UMH3N; SOT65P210X100-6N
R10, R11: 470Ω; R0805
R12: 47k(1%); R0805
R13: 10k(1%); R0805
SJR1: ESP-12E; ESP8266-ESP12E
U3: CH340C; SOIC16
U4: TXS0104; TSSOP14
VR1: RK09K1130AAU; RK09K1130BGM

Connections:
3.3V: C11.2, C13.+, C14.2, C15.2, J6.P$2 (-2), SJR1.8 (VCC), U3.4 (V3), U3.16 (VCC), U4.1 (VCCA), U4.8 (OE); also elsewhere on the board
5V: C12.2, J2.P$2 (-2), J3.P$2 (-2), J4.P$2 (-2), J5.P$1 (-1), J8.P$2 (-2), J9.P$2 (-2), J10.P$2 (-2), J11.P$2 (-2), U4.14 (VCCB), VR1.3; also elsewhere on the board
12V: J7.P$2 (-2); also elsewhere on the board
ADC: R12.1, R13.2, SJR1.2 (ADC)
CS0_ESP: SJR1.17 (CS0)
D+_USB: U3.5 (D+); also elsewhere on the board
D-_USB: U3.6 (D-); also elsewhere on the board
DTR: Q1.2, Q1.4, U3.13 (DTR)
EN: SJR1.3 (EN); also elsewhere on the board
GND: C11.1, C12.1, C13.-, C14.1, C15.1, J2.P$1 (-1), J3.P$1 (-1), J3.P$8 (-8), J4.P$1 (-1), J6.P$1 (-1), J7.P$1 (-1), J8.P$1 (-1), J9.P$1 (-1), J10.P$1 (-1), J11.P$1 (-1), R13.1, SJR1.9 (GND), U3.1 (GND), U4.7 (GND), VR1.1; also elsewhere on the board
GPIO0: Q1.3, R11.1, SJR1.12 (GPIO0); also elsewhere on the board
GPIO2: J8.P$4 (-4), SJR1.11 (GPIO2); also elsewhere on the board
GPIO4: J6.P$4 (-4), SJR1.13 (GPIO4), U4.3 (A2)
GPIO5: J6.P$3 (-3), SJR1.14 (GPIO5), U4.2 (A1)
GPIO9: SJR1.19 (GPIO9)
GPIO10: SJR1.20 (GPIO10)
GPIO12: J7.P$4 (-4), SJR1.6 (GPIO12)
GPIO13: J10.P$3 (-3), SJR1.7 (GPIO13)
GPIO14: R10.1, SJR1.5 (GPIO14)
GPIO15: J11.P$3 (-3), SJR1.10 (GPIO15); also elsewhere on the board
GPIO16: SJR1.4 (GPIO16)
LED+: J3.P$7 (-7), J5.P$2 (-2)
MISO_ESP: SJR1.18 (MISO)
MOSI_ESP: SJR1.21 (MOSI)
unnamed: J3.P$3 (-3), VR1.2
unnamed: J9.P$3 (-3), R12.2
unnamed: J7.P$3 (-3), R10.2
unnamed: J8.P$3 (-3), R11.2
RST: Q1.6, SJR1.1 (RST); also elsewhere on the board
RTS: Q1.1, Q1.5, U3.14 (RTS)
RXD: SJR1.15 (RXD), U3.2 (TX)
SCLK_ESP: SJR1.22 (SCLK)
SCL_5V: J2.P$3 (-3), J3.P$4 (-4), J4.P$3 (-3), U4.13 (B1)
SDA_5V: J2.P$4 (-4), J3.P$5 (-5), J4.P$4 (-4), U4.12 (B2)
TXD: SJR1.16 (TXD), U3.3 (RX)

Notes on the sheet:
SCL
SDA
sensor_TX
sensor_RX
Multiply ADC reading by 5.7 to get analog voltage(0~6V)
RST(N.C)
LED+
LED-
SCL/SDA : D1/D2 (5/4) 미세먼지센서: D3/D4 (0/2) 라돈센서: D5/D6 (14/12) Button1: D7 (13) Button2: D8 (15) Analog: ADC
VDD
VSS

Board: 2 copper layers, 52.0 x 60.0 mm, 50 parts (0 on the bottom side), 32 nets.

File _PCB/ESP12_DevBoard/OUTPUT/BOM.xlsx:

| BOM for ESP-12E Dev Board
 | Qty | Designator | Value | Package | MANUFACTURER_NAME | MANUFACTURER_PART_NUMBER | Total Price | Price | Link
 | 2 | C1, C4 | 10uF | C0805 | Samsung Electro-Mechanics | CL21A106KAYNNNE | 2.8000000000000001E-2 | 1.4E-2 | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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
 | 6 | C2, C3, C8, C11, C13 | 0.1uF | C0805 | Samsung Electro-Mechanics | CL21F104ZBCNNNC | 3.6000000000000004E-2 | 6.0000000000000001E-3 | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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
 | 2 | C5, C10 | 22uF | C0805 | Samsung Electro-Mechanics | CL21A226MAQNNNF | 0.19220000000000001 | 9.6100000000000005E-2 | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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
 | 2 | C6, C12 | 100uF | SMC_B | AVX | TAJB107M010RNJ | 0.27039999999999997 | 0.13519999999999999 | https://lcsc.com/product-detail/Tantalum-Capacitors_AVX_TAJB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
 | 2 | C7, C9 | 220uF | 6.3*7.7mm | ROQANG | VT1C221M0607 | 5.2999999999999999E-2 | 2.6499999999999999E-2 | https://lcsc.com/product-detail/Aluminum-Electrolytic-Capaci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
 | 2 | D1, D2 | 1N5819W | SOD-123F | Shandong Jingdao Microelectronics | 1N5819W | 2.3199999999999998E-2 | 1.1599999999999999E-2 | https://lcsc.com/product-detail/Schottky-Barrier-Diodes-SBD_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
 | 1 | J1 | ZX62-B-5PA(33) | ZX62B5PA33 | Hirose | ZX62-B-5PA(33) | 0.43109999999999998 | 0.43109999999999998 | https://lcsc.com/product-detail/USB-Connectors_HRS_ZX62-B-5P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
 | 5 | J2, J4, J6, J7, J10 | 4 |  | MOLEX | 99990988 | 0.19900000000000001 | 3.9800000000000002E-2 | https://lcsc.com/product-detail/Wire-To-Board-Wire-To-Wire-C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
 | 1 | J3 | 8 |  | MOLEX | 99990992 | 0.51700000000000002 | 0.51700000000000002 | https://www.mouser.com/ProductDetail/Molex/22-03-5085?qs=sGA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
 | 1 | J5 | 2 |  | MOLEX | 22035025 | 3.27E-2 | 3.27E-2 | https://lcsc.com/product-detail/Wire-To-Board-Wire-To-Wire-C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
 | 3 | J8, J9, J11 | 3 |  | MOLEX | 22035035 | 9.7500000000000003E-2 | 3.2500000000000001E-2 | https://lcsc.com/product-detail/Wire-To-Board-Wire-To-Wire-C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
 | 1 | JP1 | 5.5*2.1mm | 14.0*9.0mm | Korean Hroparts Elec | DC-005-20A | 5.8599999999999999E-2 | 5.8599999999999999E-2 | https://lcsc.com/product-detail/Power-Connectors_Korean-Hrop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
 | 1 | LED1 | green | LED0805 | Orient | ORH-G35A | 1.03E-2 | 1.03E-2 | https://lcsc.com/product-detail/Light-Emitting-Diodes-LED_08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
 | 1 | Q1 | UMH3N | SOT65P210X100-6N | Changjiang Electronics Tech | UMH3N | 2.18E-2 | 2.18E-2 | https://lcsc.com/product-detail/Digital-Transistors_Changjia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
 | 7 | R1, R2, R3, R4, R5, R6, R13 | 10k | R0805 | Uniroyal Elec | 0805W8F1002T5E | 8.3999999999999995E-3 | 1.1999999999999999E-3 | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
 | 1 | R12 | 47k(1%) | R0805 | Uniroyal Elec | 0805W8F4702T5E | 1.2999999999999999E-3 | 1.2999999999999999E-3 | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
 | 3 | R7, R10, R11 | 470 | R0805 | Guangdong Fenghua Advanced Tech | RS-05K471JT | 3.0000000000000001E-3 | 1E-3 | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
 | 2 | S1, S2 | pushbutton | 6.0*3.5mm | HYP (Hongyuan Precision) | 1TS002B-2300-5000-CT | 4.48E-2 | 2.24E-2 | https://lcsc.com/product-detail/Others_HYP-1TS002B-2300-5000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
 | 1 | SJR1 | ESP-12E | ESP8266-ESP12E | AI-Thinker | ESP-12E | 2.0472999999999999 | 2.0472999999999999 | https://lcsc.com/product-detail/WIFI-Modules_ESP-12E_C89297.html
 | 1 | U1 | 5V regulator | SOT-223 | Diodes Incorporated | AZ1117H-5.0TRE1 | 6.5199999999999994E-2 | 6.5199999999999994E-2 | https://lcsc.com/product-detail/Low-Dropout-Regulators-LDO_D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
 | 1 | U2 | 3.3V regulator | SOT-223 | Diodes Incorporated | AZ1117H-3.3TRG1 | 0.06 | 0.06 | https://lcsc.com/product-detail/Low-Dropout-Regulators-LDO_D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
 | 1 | U3 | CH340C | SOP-16_150mil | Jiangsu Qin Heng | CH340C | 0.28160000000000002 | 0.28160000000000002 | https://lcsc.com/product-detail/USB_CH340C_C84681.html
 | 1 | VR1 | 10k variable | RK09K1130BGM | ALPS Electric | RK09K1130AAU | 0.33250000000000002 | 0.33250000000000002 | https://lcsc.com/product-detail/Potentiometers-Variable-Resi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
 |  |  |  |  |  |  | SUM
 |  |  |  |  |  |  | 4.8148999999999997

## EAGLE design _PCB/LoRa sensor node_MAKER/board.brd

Parts:
BME280_1-3, BME280_4-6: CONN_03; 1X03
C1, C2: CPOL-EUD; PANASONIC_D
C3, C8, C9: 100nF; C0805
C6: 220uF; E2,5-5
GP2Y10: CONN_05; 1X05
GP2Y10_2: CONN_05PTH_LONGPADS; 1X05_LONGPADS
H1: DRILL_0.3650_GP2Y10; PAD_0.3650
JP1: Vout; SMT-JUMPER_2_NC_TRACE_SILK
JP2: PINHD-2X18; 2X18
JP3: PINHD-2X13; 2X13
JP4, JP5, JP6, JP7: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
JP8, JP9: PINHD-2X2/OCT; 2X02
R1: 150Ω; 0204/7
SW1: SW_DIP-4; EDG-04
USB1, USB2, USB3: ST-USB-001G; MICRO-USB5+4P-SMD-0.65-B

Connections:
3.3V: BME280_1-3.1, C1.+, C8.1, C9.2, JP2.3, JP2.4, JP8.1, JP8.2, JP9.1, JP9.2, SW1.5, SW1.6, SW1.7, SW1.8
5V: C2.+, C3.1, GP2Y10.5, GP2Y10_2.5, JP3.1, JP3.2, R1.2, USB1.5 (GND), USB2.5 (GND), USB3.5 (GND)
DIP1: JP2.5, JP2.6, JP7.2
DIP2: JP2.7, JP2.8, JP6.2
DIP3: JP2.9, JP2.10, JP5.2
DIP4: JP2.11, JP2.12, JP4.2
GND: BME280_1-3.2, C1.-, C2.-, C3.2, C6.-, C8.2, C9.1, GP2Y10.2, GP2Y10.3, GP2Y10_2.2, GP2Y10_2.3, JP2.1, JP2.2, JP3.3, JP3.4, JP8.3, JP8.4, JP9.3, JP9.4, USB1.1 (VCC), USB1.S1 (GND), USB1.S2 (GND), USB1.S3 (GND), USB1.S4 (GND), USB2.1 (VCC), USB2.S1 (GND), USB2.S2 (GND), USB2.S3 (GND), USB2.S4 (GND), USB2.S5 (GND), USB2.S6 (GND), USB3.1 (VCC), USB3.S1 (GND), USB3.S2 (GND), USB3.S3 (GND), USB3.S4 (GND), USB3.S5 (GND), USB3.S6 (GND)
unnamed: JP7.1, SW1.1
unnamed: JP6.1, SW1.2
unnamed: JP2.33, JP2.34
unnamed: JP2.31, JP2.32
unnamed: JP2.27, JP2.28
unnamed: JP2.25, JP2.26
unnamed: JP3.25, JP3.26
unnamed: JP3.23, JP3.24
unnamed: JP3.21, JP3.22
unnamed: JP3.17, JP3.18
unnamed: JP5.1, SW1.3
unnamed: JP3.15, JP3.16
unnamed: JP3.13, JP3.14
unnamed: JP3.11, JP3.12
unnamed: JP3.9, JP3.10
unnamed: JP3.7, JP3.8
unnamed: JP3.5, JP3.6
unnamed: JP4.1, SW1.4
unnamed: JP2.13, JP2.14
unnamed: JP2.15, JP2.16
unnamed: JP2.17, JP2.18
unnamed: JP2.19, JP2.20
unnamed: JP2.21, JP2.22
unnamed: JP2.23, JP2.24
SCL: BME280_1-3.3, JP2.29, JP2.30
SDA: BME280_4-6.1, JP2.35, JP2.36
VLED: C6.+, GP2Y10.4, GP2Y10_2.4, R1.1
VOUT: JP1.2, JP3.19, JP3.20
VOUT_1: GP2Y10.1, GP2Y10_2.1, JP1.1

Notes on the sheet:
Vout
LED-GND
GND
VLED
VCC
LoRa
3.3v
RST
3.3V
SCL
SDA
NCS
SDO

Board: 2 copper layers, 47.9 x 78.2 mm, 24 parts (2 on the bottom side), 36 nets.

## EAGLE design _PCB/MPU6050 Mouse/schematic.brd

Board: 2 copper layers, 86.4 x 36.5 mm, 30 parts (1 on the bottom side), 20 nets.

Parts:
3.3V: 1X03
B1: SPARKFUN_PRO_MICRO
C_5V_1: C0805
GY521_2: 1X08
GY-521: 1X06_LOCK
GY_3.3V: 3.3V; SMT-JUMPER_2_NO_NO-SILK
GY_5V_DEFAULT: 5V; SMT-JUMPER_2_NC_TRACE_SILK
H1, H2, H3, H4: MOUNT-HOLE3.0; 3,0
IC1: REG1117; SOT223
IN: 100nF; E2,5-5
IN_2: C0805
J2, J6: 1X02_LOCK
JP_L: SMT-JUMPER_2_NC_TRACE_SILK
JP_R: SMT-JUMPER_2_NC_TRACE_SILK
JP_SCL: SMT-JUMPER_2_NC_TRACE_SILK
JP_SDA: SMT-JUMPER_2_NC_TRACE_SILK
LEFT: TACTILE_SWITCH_PTH_6.0MM
MICRO_2: USB-MICROB
OUT: 100nF; E2,5-5
OUT_2: C0805
POWER: FEMALE 2x3; 2X3
RESET1: TACTILE_SWITCH_PTH_6.0MM
RESET2: 6*3.5mm; TACTILE_SWITCH_SMD_6.0X3.5MM
RIGHT: TACTILE_SWITCH_PTH_6.0MM
SHIELD: R0805
U1: GY-521MPU6050; GY-521

Connections:
3.3V: 3.3V.1, 3.3V.2, 3.3V.3, GY_3.3V.2, IC1.2, OUT.+, OUT_2.1
5V: B1.21, C_5V_1.1, GY_5V_DEFAULT.2, IC1.3, IN.+, IN_2.1, MICRO_2.VBUS, POWER.1, POWER.3, POWER.5
D+: J6.2, MICRO_2.D+
D-: J6.1, MICRO_2.D-
GND: B1.4, B1.23, C_5V_1.2, GY521_2.2, IC1.1, IN.-, IN_2.2, LEFT.3, MICRO_2.GND, OUT.-, OUT_2.2, POWER.2, POWER.4, POWER.6, RESET1.3, RESET2.2, RIGHT.3, SHIELD.2, U1.GND
unnamed: J2.2, JP_L.2, LEFT.1
unnamed: J2.1, JP_R.2, RIGHT.1
unnamed: B1.8, JP_R.1
unnamed: B1.9, JP_L.1
unnamed: GY521_2.1, GY_3.3V.1, GY_5V_DEFAULT.1, U1.VCC
unnamed: B1.22, RESET1.1, RESET2.1
unnamed: MICRO_2.MT1, MICRO_2.MT2, MICRO_2.P$1, MICRO_2.P$2, SHIELD.1
unnamed: B1.2, JP_SDA.2
unnamed: B1.3, JP_SCL.2
unnamed: GY521_2.8, GY-521.1, U1.INT
unnamed: GY521_2.7, GY-521.2, U1.ADO
unnamed: GY521_2.6, GY-521.3, U1.XCL
unnamed: GY521_2.5, GY-521.4, U1.XDA
SCL: GY521_2.3, GY-521.6, JP_SCL.1, U1.SCL
SDA: GY521_2.4, GY-521.5, JP_SDA.1, U1.SDA

## EAGLE design _PCB/NANO.ProMini prototype board/board.brd

Board: 2 copper layers, 93.2 x 100.1 mm, 74 parts (5 on the bottom side), 82 nets.

Parts:
3.3/5: 1X03_LOCK
3.3V, 5V: 1X05_LOCK_LONGPADS
3.3V_C: E2,5-5
5V_C: E3,5-8
B1: BREADBOARDMINI; BREADBOARD-MINI
BOARD_POWER: 1X04_LOCK_LONGPADS
CP2102_USB-SERIAL: USB-SERIAL-CP2102
ES32-433T20D: 1X07_LOCK
ESP1: 1k; 0207/7
ESP1_1, ESP2_1: R2012
ESP2: 2k; 0207/7
ESP8266: WIRELESS-WIFI-ESP-01
ESP_C: E2,5-5
ESP_H: 2X3
ESP_POW: 1X02_LOCK
GND: 1X05_LOCK_LONGPADS
GY-521: 1X08_LOCK
GY_4-8: 1X04_LOCK
H1, H2, H3, H4: MOUNT-HOLE3.0; 3,0
J1, J6: 1X05_LOCK
J2, J3: 1X02_LOCK_LONGPADS
J4, J8: 1X04_LOCK
J5, J7, J9: 1X06_LOCK
MICRO_1, MICRO_2: USB-MICROB
MINI_1: USB_MINI-B_SMT; USB-MINIB
NANO: NANO
NRF24L01: WIRELESS-NRF24L01
PAD1, PAD2, PAD3, PAD4, PAD5, PAD6, PAD7, PAD8, PAD9, PAD10: SMD1,27-2,54
PH1, PH2: 2X15
PIEZO: 1X02_LOCK
PIEZO_: F/CM12P
PIN1, PIN2, PIN3: 1X02_LOCK
PROMINI_H: 1X06/OCT
R1: 4.7k; 0207/7
R1_1, R2_1: R2012
R2: 4.7K; 0207/7
RA-02: LORA-RA2-SMD
RAW: POWER_JACK_SLOT
S1, S2: MOMENTARY-SWITCH-SPST-PTH-6.0MM; TACTILE_SWITCH_PTH_6.0MM
S3, S4: DTS-3
SW1: EDG-04
T1_5MM, T2_5MM, T3_5MM: 5mm; H2-5.0-10.5X8.0MM
U$1: USB-SERIAL-FT232R
USB_B: USB-B-PTH
USB_DATA: 1X02_LOCK
VIN: 1X04_LOCK_LONGPADS

Connections:
3.3V: 3.3/5.3, 3.3V.1, 3.3V.2, 3.3V.3, 3.3V.4, 3.3V.5, 3.3V_C.+, BOARD_POWER.4, CP2102_USB-SERIAL.1, ESP8266.D2, ESP_C.+, ESP_POW.1, J3.1, J7.2, J9.1, NANO.3.3V, PAD1.1, PAD3.1, PAD5.1, PAD7.1, PH1.3, PH1.4
5V: 3.3/5.1, 5V.1, 5V.2, 5V.3, 5V.4, 5V.5, 5V_C.+, BOARD_POWER.2, CP2102_USB-SERIAL.6, GY-521.1, J7.3, J8.1, J9.6, MICRO_1.VBUS, MICRO_2.VBUS, MINI_1.VBUS, NRF24L01.2, PAD8.1, U$1.4, USB_B.VBUS
A5: GY-521.3, NANO.A5, PH1.17, PH1.18
A6: NANO.A6, PH1.19, PH1.20
A7: NANO.A7, PH1.21, PH1.22
CE_NRF: NANO.D6, NRF24L01.3, PH2.13, PH2.14
CSN_NRF: NANO.D5, NRF24L01.4, PH2.15, PH2.16
D+_5PIN: J8.3, MICRO_1.D+, MICRO_2.D+, MINI_1.D+, USB_B.D+, USB_DATA.2
D-_5PIN: J8.2, MICRO_1.D-, MICRO_2.D-, MINI_1.D-, USB_B.D-, USB_DATA.1
GND: 3.3V_C.-, 5V_C.-, CP2102_USB-SERIAL.5, ES32-433T20D.7, ESP2.1, ESP2_1.1, ESP8266.A1, ESP_C.-, GY-521.2, J7.1, J8.4, J9.5, MICRO_1.GND, MICRO_2.GND, MINI_1.GND, NANO.GND, NANO.ICSP6, NRF24L01.1, PH1.27, PH1.28, PIEZO_.-, PROMINI_H.1, RA-02.1, RA-02.2, RA-02.9, RA-02.16, RAW.GND@1, U$1.6, USB_B.GND
MISO_NRF: NANO.GND1, NRF24L01.7, PH2.23, PH2.24
MOSI_NRF: NANO.D2, NRF24L01.6, PH2.21, PH2.22
unnamed: ES32-433T20D.2, J1.2
unnamed: GY-521.5, GY_4-8.4
unnamed: NANO.AREF, PH1.5, PH1.6
unnamed: NANO.A0, PH1.7, PH1.8
unnamed: NANO.A1, PH1.9, PH1.10
unnamed: NANO.A2, PH1.11, PH1.12
unnamed: NANO.A3, PH1.13, PH1.14
unnamed: GY-521.6, GY_4-8.3
unnamed: GY-521.7, GY_4-8.2
unnamed: GY-521.8, GY_4-8.1
unnamed: 3.3/5.2, ES32-433T20D.6
unnamed: ES32-433T20D.1, J1.1
unnamed: J1.4, R1.1, R1_1.1
unnamed: J1.3, R2.1, R2_1.1
unnamed: ES32-433T20D.4, R1.2, R1_1.2
unnamed: NANO.D12, PH2.1, PH2.2
unnamed: NANO.D11, PH2.3, PH2.4
unnamed: NANO.D10, PH2.5, PH2.6
unnamed: NANO.D9, PH2.7, PH2.8
unnamed: NANO.D8, PH2.9, PH2.10
unnamed: NANO.D7, PH2.11, PH2.12
unnamed: ES32-433T20D.5, J1.5
unnamed: PIN1.2, T1_5MM.1
unnamed: NANO.D4, PH2.17, PH2.18
unnamed: NANO.D3, PH2.19, PH2.20
unnamed: PIN1.1, T1_5MM.2
unnamed: PIN2.2, T2_5MM.1
unnamed: NANO.RST1, PH2.25, PH2.26
unnamed: NANO.RX1, PH2.27, PH2.28
unnamed: NANO.TX0, PH2.29, PH2.30
unnamed: PIN2.1, T2_5MM.2
unnamed: PIN3.2, T3_5MM.1
unnamed: PIN3.1, T3_5MM.2
unnamed: PIEZO.1, PIEZO.2, PIEZO_.+
unnamed: GND.1, GND.2, GND.3, GND.4, GND.5
unnamed: BOARD_POWER.3, NANO.5V, PAD9.1, PH1.23, PH1.24, PROMINI_H.3, S1.1, S2.1, S3.1, S4.2, SW1.5, SW1.6, SW1.7, SW1.8
unnamed: J2.1, S1.3, S3.2
unnamed: ES32-433T20D.3, R2.2, R2_1.2
unnamed: J4.1, SW1.4
unnamed: J4.2, SW1.3
unnamed: J4.3, SW1.2
unnamed: J4.4, SW1.1
unnamed: J2.2, S2.3, S4.1
unnamed: J6.1, RA-02.8
unnamed: J6.2, RA-02.7
unnamed: J6.3, RA-02.6
unnamed: J6.4, RA-02.5
unnamed: J6.5, RA-02.4
unnamed: J5.1, RA-02.15
unnamed: J5.2, RA-02.14
unnamed: J5.3, RA-02.13
unnamed: J5.4, RA-02.12
unnamed: J5.5, RA-02.11
unnamed: J5.6, RA-02.10
unnamed: ESP8266.B2, ESP_POW.2, PAD2.1, PAD6.1
unnamed: CP2102_USB-SERIAL.3, J7.5, J9.3, PROMINI_H.4, U$1.2
unnamed: ESP1.1, ESP1_1.1, ESP2.2, ESP2_1.2, ESP8266.D1
unnamed: ESP8266.C2, ESP_H.2
unnamed: ESP8266.C1, ESP_H.3
unnamed: ESP1.2, ESP1_1.2, ESP_H.1
unnamed: CP2102_USB-SERIAL.4, J7.4, J9.4, PROMINI_H.5, U$1.3
unnamed: ESP8266.B1, ESP_H.5
unnamed: ESP8266.A2, ESP_H.6
unnamed: BOARD_POWER.1, PAD10.1
unnamed: CP2102_USB-SERIAL.2, J7.6, J9.2, PROMINI_H.6, U$1.1
unnamed: J3.2, PAD4.1, RA-02.3
RST: NANO.RST, PH1.25, PH1.26
SCK_NRF: NANO.D13, NRF24L01.5, PH1.1, PH1.2
SDA_GY521: GY-521.4, NANO.A4, PH1.15, PH1.16
VIN: NANO.RAW, PH1.29, PH1.30, RAW.PWR, VIN.1, VIN.2, VIN.3, VIN.4

Notices in the files:
parts and their libraries:
SparkFun-Switches: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
diy-modules: Released under the Creative Commons Attribution 4.0 International License: http://creativecommons.org/licenses/by/4.0
